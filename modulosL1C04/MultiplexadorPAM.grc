options:
  parameters:
    author: Over_Amaya_Angie_Chaparro_L1C
    copyright: '04'
    generate_options: qt_gui
    id: MultiplexadorPAM
    output_language: python
    title: Multiplexador PAM
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje Am
    start: '0'
    step: '100e-3'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho pulso D
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: D1
  id: variable_qtgui_range
  parameters:
    label: Retardo 1 D1
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    label: Retardo 2 D2
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    label: Retardo 3 D3
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje fm
    start: '0'
    step: '10'
    stop: 10e3
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Pulsos fs
    start: '0'
    step: '1'
    stop: 10e3
    value: 2e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: ModulacionPAM
  id: modulaciondepulsos
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0
  id: modulaciondepulsos
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_0
  id: modulaciondepulsos
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_0_0_0
  id: modulaciondepulsos
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModulacionPAM, '0', blocks_add_xx_0, '0']
- [ModulacionPAM, '0', qtgui_time_sink_x_2, '0']
- [ModulacionPAM_0, '0', blocks_delay_0, '0']
- [ModulacionPAM_0_0, '0', blocks_delay_0_0, '0']
- [ModulacionPAM_0_0_0, '0', blocks_delay_0_0_0, '0']
- [analog_sig_source_x_0, '0', ModulacionPAM, '0']
- [analog_sig_source_x_0_0, '0', ModulacionPAM_0, '0']
- [analog_sig_source_x_0_0_0, '0', ModulacionPAM_0_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', ModulacionPAM_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_2, '4']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_2, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_2, '2']
- [blocks_delay_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_0_0, '0', qtgui_time_sink_x_2, '3']

metadata:
  file_format: 1
