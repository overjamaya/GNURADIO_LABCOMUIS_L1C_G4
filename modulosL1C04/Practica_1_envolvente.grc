options:
  parameters:
    author: Over_Amaya_Angie_Chaparro
    copyright: UIS
    generate_options: qt_gui
    id: Practica_4_1
    output_language: python
    title: Modulacion PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora Ac
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje Am
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia transmisor GTX
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora fc
    start: 50e6
    step: 1e6
    stop: 2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje fm
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente kp
    start: '0'
    step: '1e-6'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: EnvolventeComplejaPM_0
  id: EnvolventeComplejaPM
  parameters:
    Ac: Ac
    Kp: kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventeComplejaPM_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeComplejaPM_0, '0', qtgui_time_sink_x_0, '0']
- [EnvolventeComplejaPM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeComplejaPM_0, '0']

metadata:
  file_format: 1
