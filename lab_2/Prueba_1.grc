options:
  parameters:
    author: Over_Amaya_Angie_chaparro
    generate_options: qt_gui
    id: Prueba_1
    output_language: python
    title: Over_Amaya_Angie_chaparro
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: CalculoDePotenciaComunicaciones_0
  id: CalculoDePotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [analog_sig_source_x_0, '0', CalculoDePotenciaComunicaciones_0, '0']

metadata:
  file_format: 1
